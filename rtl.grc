options:
  parameters:
    generate_options: qt_gui
    id: rtl
    output_language: python
    title: SDR audio search
  states: {}

blocks:
- name: audio_bw
  id: variable
  parameters:
    value: audio_rate/2
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Audio Gain
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '10'
    value: '1'
    widget: dial
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: bw_factor
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BW adjust
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '1'
    widget: dial
  states: {}
- name: centre_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Centre Frequency
    orient: Qt.Horizontal
    start: 20e6
    step: 1.0e6
    stop: 1.7e9
    value: 500e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: int(samp_rate/audio_rate)
  states: {}
- name: demod_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Demodulation mode
    label0: AM
    label1: FM
    label2: Raw
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
  states: {}
- name: filter_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Input Gain
    orient: Qt.Horizontal
    start: '0.8'
    step: '0.1'
    stop: '8'
    value: '1.0'
    widget: dial
  states: {}
- name: fine_grained_centre_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Fine grained centre freq
    orient: Qt.Horizontal
    start: '-1e6'
    step: 1e3
    stop: 1e6
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: centre_freq+fine_grained_centre_freq
  states: {}
- name: mute
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 1,4,1,1
    label: Mute
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Squelch
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
    widget: counter
  states: {}
- name: squelch_on
  id: variable_qtgui_check_box
  parameters:
    'false': '-500'
    gui_hint: 1,2,1,1
    label: Squelch On
    'true': '0'
    type: int
    value: '0'
  states: {}
- name: squelch_value
  id: variable
  parameters:
    value: squelch_on+squelch
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 0.8*audio_bw
    audio_stop: 0.95*audio_bw
    chan_rate: audio_rate
    deviation: '1000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch_value
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:CARD=AudioPCI,DEV=0
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: audio_gain * (1-mute)
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demod_mode
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: ./signals.wav
    samp_rate: audio_rate
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '25'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '25'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: bw_factor*(audio_bw-1e3)
    decim: decimation
    gain: filter_gain
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_3
  id: qtgui_sink_x
  parameters:
    bw: audio_bw
    fc: freq
    fftsize: '1024'
    gui_hint: 3,2,1,2
    name: '"Demodulated"'
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 3,4,1,2
    legend: 'False'
    name: Signal
    size: audio_rate//2
    srate: audio_rate
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 2,0,1,6
    name: '"IF"'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,2
    name: '"Downsampled"'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: rtlsdr
    overall_gain0: '10'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_selector_1, '1']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', high_pass_filter_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_1, '2']
- [blocks_copy_0, '0', qtgui_sink_x_3, '0']
- [blocks_copy_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', audio_sink_0, '0']
- [blocks_selector_1, '0', blocks_copy_0, '0']
- [blocks_selector_1, '0', blocks_wavfile_sink_0, '0']
- [blocks_selector_1, '0', virtual_sink_1, '0']
- [high_pass_filter_0, '0', blocks_selector_1, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_1, '0']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [soapy_source_0, '0', low_pass_filter_1, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', analog_simple_squelch_cc_0, '0']
- [virtual_source_0, '0', blocks_complex_to_real_0, '0']
- [virtual_source_1, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
